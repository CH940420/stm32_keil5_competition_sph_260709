# Keil uVision project PWM.uvprojx, settings and files
target PWM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\SHIP;..\FWLIB\inc;..\HARDWARE\SBUS;..\HARDWARE\SYSTEM1;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\HARDWARE\GPS;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\UCOSII\CONFIG;..\HARDWARE\UCOSII\CORE;..\HARDWARE\UCOSII\PORT;..\HARDWARE\USART2;..\HARDWARE\wit_c_sdk;..\HARDWARE\USART4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/SBUS/: SBUS.c
    ../HARDWARE/SYSTEM1/: system.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SHIP/: ship.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/USART2/: UART2.c
    ../HARDWARE/wit_c_sdk/: wit_c_sdk.c
    ../HARDWARE/USART4/: usart4.c usart4.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_fsmc.c
  group UCOSII-CORE
    ../HARDWARE/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../HARDWARE/UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../HARDWARE/UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: readme.txt
